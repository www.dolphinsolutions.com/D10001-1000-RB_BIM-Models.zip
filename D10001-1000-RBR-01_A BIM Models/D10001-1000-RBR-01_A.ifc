Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2026-04-08T16:14:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 08 16:14:36 2026 * Host: Yoga * Database: D:\Temp\fc611c4b-5023-439d-9981-df5257fdc4ad\663bbc50-dbc3-4972-aa25-c3b394d8fe63\ifc * Database version: 5507 * Database creation date: Wed Apr 08 16:14:34 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 08 16:14:34 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 08 16:14:34 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum

# IfcFlowTerminal: AL0220:AL0220, AL0220:AL0220:1094401
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: AL0220
Type - Other - Category: Plumbing Fixtures; Family Name: AL0220
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_DistributionFlowElementCommon - Reference: AL0220:AL0220; sets with these values: 2
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 720 mm; Host: Level : Level 0; Offset from Host: 720 mm
Dimensions - Area: 0.00000628277 m2; Volume: 3.1402e-09 m3
Identity Data - Mark: 685
Other - Family: AL0220: AL0220; Family and Type: AL0220: AL0220; Type: AL0220: AL0220; Type Id: AL0220: AL0220
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC2008:BC2008 Dolphin Slimline Eco Hand Dryer, BC2008:BC2008 Dolphin Slimline Eco Hand Dryer:356950
In: Level 0
Type - Classification: D2010900 Other Plumbing Fixtures (Uniformat); Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 101 mm; Height: 270.2 mm; Width: 161.4 mm
Type - Identity Data - AccessibilityPerformance: n/a; Assembly Code: D2010900; Assembly Description: Other Plumbing Fixtures; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; BodyIngressProtectionMinimum: IP24; Category: Pr_40_70_62_37:Hand dryers; CodePerformance: n/a; Color: Brushed satin/ White_BC2008W/PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; DurationUnit: year; ElectricalSupplyFrequency: 50/ 60 Hz; ElectricalSupplyPowerRating: 500-900 W; ElectricalSupplyRatedOperationalVoltage: 220-240 V a.c; ExpectedLife: n/a; Features: Touch free; Finish: BrushedSatin Suffix_-PVD_-PCPowderCoated_-CCCeramicCoated; Form: High-velocity air; Grade: n/a; InstallationDate: 31-12-1900 23:59; Manufacturer: Dolphin Solutions Limited; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: n/a; Model: BC2008; ModelNumber: BC2008/ BC2008W; ModelReference: DolphinSolutionsLimited_VelocityMiniHandDryer; Name: HandDryers_VelocityMiniHandDryer_BC2008_DolphinSolutionsLimited; NBSDescription: Hand dryers; NBSReference: 45-35-72/334; NBSTypeID: n/a; NoiseLevelAt1MMaximum: 76.6 dB(A); NominalHeight: 270; NominalLength: 101; NominalWidth: 162; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.14; Operation: Automatic; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-mini-hand-dryer-bc2008/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 162 x 270 x 101 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC2008 Dolphin Slimline Eco Hand Dryer; Uniclass2015Code: Pr_40_70_62_37; Uniclass2015Title: Hand dryers; URL: www.dolphinsolutios.co.uk; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC2008
Type - Pset_ElementShading - Color: Brushed satin/ White_BC2008W/PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_VelocityMiniHandDryer; Manufacturer: Dolphin Solutions Limited
Type - Pset_ProductRequirements - Name: HandDryers_VelocityMiniHandDryer_BC2008_DolphinSolutionsLimited; Category: Pr_40_70_62_37:Hand dryers
Pset_DistributionFlowElementCommon - Reference: BC2008:BC2008 Dolphin Slimline Eco Hand Dryer; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 800 mm; Host: Level : Level 0; Offset from Host: 800 mm
Dimensions - Area: 0.0910884 m2; Volume: 0.0043877 m3
Identity Data - Mark: 10
Other - Family: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer; Family and Type: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer; Type: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer; Type Id: BC2008: BC2008 Dolphin Slimline Eco Hand Dryer
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC238SS:BC238SS, BC238SS:BC238SS:1094388
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 103.5 mm; Height: 286 mm; Width: 125 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Capacity: 1000 ml; Category: Pr_40_70_22_81:Soap dispensers; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Wall mounted soap or sanitiser dispenser; DurationUnit: year; ElectricalSupplyPowerRating: 4 x C cell batteries; ElectricalSupplyRatedOperationalVoltage: Optional3VMainSupply; ExpectedLife: n/a; Features: TouchFree_Liquid_or_Sanitiser_Cartridge; Finish: BrushedSatin Suffix_-PVD_-PCPowderCoated_-CCCeramicCoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC238SS; ModelReference: DolphinSolutionsLimited_WallMountedTouchFreeLiquidSoapSanitiserDispenser; Name: SoapDispensers_TouchFree_SoapSanitiserDispenser_BC238SS_DolphinSolutionsLimited; NBSDescription: Soap dispensers; NBSReference: 45-35-72/358; NBSTypeID: n/a; NominalHeight: 268; NominalLength: 104; NominalWidth: 125; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.34; Operation: Automatic; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-auto-soap-sanitiser-dispenser/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 125 x 268 x 104 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC238SS; Uniclass2015Code: Pr_40_70_22_81; Uniclass2015Title: Soap dispensers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC238SS
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_WallMountedTouchFreeLiquidSoapSanitiserDispenser; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: SoapDispensers_TouchFree_SoapSanitiserDispenser_BC238SS_DolphinSolutionsLimited; Category: Pr_40_70_22_81:Soap dispensers
Pset_DistributionFlowElementCommon - Reference: BC238SS:BC238SS; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 800 mm; Host: Level : Level 0; Offset from Host: 800 mm
Dimensions - Area: 0.0782756 m2; Volume: 0.00369491 m3
Identity Data - Mark: 672
Other - Family: BC238SS: BC238SS; Family and Type: BC238SS: BC238SS; Type: BC238SS: BC238SS; Type Id: BC238SS: BC238SS
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC4302:BC4302, BC4302:BC4302:356951
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Width: 145.5 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_88:Toilet roll holders; CodePerformance: n/a; Color: Brushed Satin/ BC4302B_Polished; Constituents: n/a; Description: Toilet tissue dispenser; DurationUnit: year; ExpectedLife: n/a; Features: Bulk Pack Tissue; Finish: Brushed Satin/ Polished_BC4302B; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC4302/BC4302B; ModelReference: DolphinSolutionsLimited_ToiletTissueDispenser; Name: ToiletTissueDispenser_BulkPack_BC4302_DolphinSolutionsLimited; NBSDescription: Toilet roll holders; NBSReference: 45-35-72/366; NBSTypeID: n/a; NominalHeight: 240 mm; NominalLength: 111 mm; NominalWidth: 145 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.21; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-toilet-tissue-dispenser-bc4302/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 145 x 240 x 111 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC4302; Uniclass2015Code: Pr_40_20_76_88; Uniclass2015Title: Toilet roll holders; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC4302
Type - Pset_ElementShading - Color: Brushed Satin/ BC4302B_Polished
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ToiletTissueDispenser; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ToiletTissueDispenser_BulkPack_BC4302_DolphinSolutionsLimited; Category: Pr_40_20_76_88:Toilet roll holders
Pset_DistributionFlowElementCommon - Reference: BC4302:BC4302; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 800 mm; Host: Level : Level 0; Offset from Host: 800 mm
Dimensions - Area: 0.0829836 m2; Volume: 0.00350184 m3
Identity Data - Mark: 11
Other - Family: BC4302: BC4302; Family and Type: BC4302: BC4302; Type: BC4302: BC4302; Type Id: BC4302: BC4302
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5023-07SS:Standard, BC5023-07SS:Standard:356942
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 800 mm; Height: 140 mm; Width: 100 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182_DocM_BS8300; Color: Brushed Satin Polished-PSS; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: 800mm Fold Down; Finish: Brushed Satin/ Polished-PSS; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5023-07SS/BC5023-07-PSS; ModelReference: DolphinSolutionsLimited_32mmGrabRail; Name: SupportRails_800mmFoldDown32mmGrabRail_BC5023-07SS_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 139 mm; NominalLength: 800 mm; NominalWidth: 100 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-contemporary-grab-rail/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 800 x 100 x 139 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5023-07SS
Type - Pset_ElementShading - Color: Brushed Satin Polished-PSS
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmGrabRail
Type - Pset_ProductRequirements - Name: SupportRails_800mmFoldDown32mmGrabRail_BC5023-07SS_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Pset_DistributionFlowElementCommon - Reference: BC5023-07SS:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Elevation from Level: 498.5 mm; Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no; Offset from Host: 498.5 mm
Dimensions - Area: 0.0683182 m2; Volume: 0.000693445 m3
Identity Data - Mark: 2
Other - Family: BC5023-07SS: Standard; Family and Type: BC5023-07SS: Standard; Type: BC5023-07SS: Standard; Type Id: BC5023-07SS: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5063-02:Standard (4)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Depth: 76 mm; Diameter: 32 mm; Width: 600 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CodePerformance: BSEN12182; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Roseless 60mm wall clearance; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5063-02; ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Name: SupportRails_Roseless32mmGrabRail_BC5063-02_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 92 mm; NominalLength: 600 mm; NominalWidth: 32 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-roseless-stainless-steel-grab-rail-32mm/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 600 x 32 x 92 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5063-02
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail
Type - Pset_ProductRequirements - Name: SupportRails_Roseless32mmGrabRail_BC5063-02_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Pset_DistributionFlowElementCommon - Reference: BC5063-02:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0
Dimensions - Area: 0.0662086 m2; Volume: 0.00013204 m3
Other - Family: BC5063-02: Standard; Family and Type: BC5063-02: Standard; Type: BC5063-02: Standard; Type Id: BC5063-02: Standard
Phasing - Phase Created: New Construction
Name (BC5063-02:Standard:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
356943 | 1100 | 3
356945 | 1100 | 5
356946 | 1100 | 6
356947 | 664 | 7

# IfcFlowTerminal: BC5064-08:Standard, BC5064-08:Standard:1094400
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 200 mm; Diameter: 35 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_98:WCPanBackRests; CodePerformance: DocM_BS8300; Color: Brushed Satin or PSSPolished; Constituents: n/a; Description: Back rest bar; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin/PSSPolished; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5064-08/BC5064-08PSS; ModelReference: DolphinSolutionsLimited_32mmBackRest; Name: WCPanBackRests_32mmBackRestBar_BC5064-08_DolphinSolutionsLimited; NBSDescription: WC Pan Back Rests; NBSReference: 45-35-72/382; NBSTypeID: n/a; NominalHeight: 218 mm; NominalLength: 400 mm; NominalWidth: 32 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-roseless-stainless-steel-back-rest-rail-2/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 400 x 218 x 32 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_98; Uniclass2015Title: WC Pan Back Rests; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5064-08
Type - Pset_ElementShading - Color: Brushed Satin or PSSPolished
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_32mmBackRest; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WCPanBackRests_32mmBackRestBar_BC5064-08_DolphinSolutionsLimited; Category: Pr_40_20_76_98:WCPanBackRests
Pset_DistributionFlowElementCommon - Reference: BC5064-08:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 664 mm; Host: Level : Level 0; Offset from Host: 664 mm
Dimensions - Area: 0.0727186 m2; Volume: 0.000253303 m3
Identity Data - Mark: 684
Other - Family: BC5064-08: Standard; Family and Type: BC5064-08: Standard; Type: BC5064-08: Standard; Type Id: BC5064-08: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-101:Standard, BC5083-101:Standard:356953
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 10 mm; Height: 1000 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_25_71_53_06:Bathroom mirrors; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Form: Wall-mounted; Grade: n/a; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Glass; ModelNumber: BC5083-101; ModelReference: DolphinSolutionsLimited_Mirror; Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; NBSDescription: Bathroom mirrors; NBSReference: 45-35-72/336; NBSTypeID: n/a; NominalHeight: 1000; NominalLength: 15; NominalWidth: 400; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.95.17.17; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 400 x 1000 x 15 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_25_71_53_06; Uniclass2015Title: Bathroom mirrors; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-101
Type - Pset_ElementShading - Color: n/a
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Mirror
Type - Pset_ProductRequirements - Name: BathroomMirrors_Mirror_BC5083-101_DolphinSolutionsLimited; Category: Pr_25_71_53_06:Bathroom mirrors
Pset_DistributionFlowElementCommon - Reference: BC5083-101:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 600 mm; Host: Level : Level 0; Offset from Host: 600 mm
Dimensions - Area: 0.827875 m2; Volume: 0.004 m3
Identity Data - Mark: 13
Other - Family: BC5083-101: Standard; Family and Type: BC5083-101: Standard; Type: BC5083-101: Standard; Type Id: BC5083-101: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-121:Standard, BC5083-121:Standard:356952
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 2500 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits; CodePerformance: BS8300:DocM; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: BS8300:DocM_PullCord_OpenDoorIndicator_ResetButton; Finish: Brushed Satin; Form: Surface-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-121; ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit; Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; NBSDescription: AssistanceCallPulCordUnits; NBSReference: 90-70-05/320; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 0; NominalWidth: 0; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.85.30.24.11; Operation: PullCord; ProductInformation: https://www.nationalbimlibrary.com/en-gb/vox-ignis-limited/vilx-cpp-assist-call-pull-cord-plate/?lo=en-GB; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_75_75_04_04; Uniclass2015Title: AssistanceCallPulCordUnits; Uniclass2015Version: Products v1.15; Version: 1; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-121
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_AssistanceCallPulCordUnit
Type - Pset_ProductRequirements - Name: AssistanceCallPulCordUnits_AssistanceCallPulCordUnit_BC5083-121_DolphinSolutionsLimited; Category: Pr_75_75_04_04:AssistanceCallPulCordUnits
Pset_DistributionFlowElementCommon - Reference: BC5083-121:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Offset from Host: 0 mm; Host: Level : Level 0
Dimensions - Area: 0.0221672 m2; Volume: 0.000127718 m3
Identity Data - Mark: 12
Other - Family: BC5083-121: Standard; Family and Type: BC5083-121: Standard; Type: BC5083-121: Standard; Type Id: BC5083-121: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC5083-PAD-WH:Standard, BC5083-PAD-WH:Standard:1094399
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 50 mm; Diameter: 35 mm; Height: 160 mm; Width: 360 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_98:WCPanBackRests; CodePerformance: DocM_BS8300; Color: White; Constituents: n/a; Description: White back rest pad; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: ClosedCellPolyurathane; ModelNumber: BC5083-PAD-WH; ModelReference: DolphinSolutionsLimited_WhiteBackRestPad; Name: WCPanBackRests_WhiteBackRestPad_BC5083-PAD-WH_DolphinSolutionsLimited; NBSDescription: WC Pan Back Rests; NBSReference: 45-35-72/382; NBSTypeID: n/a; NominalHeight: 160 mm; NominalLength: 365 mm; NominalWidth: 50 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-water-resistant-pu-back-rest-pad/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 365 x 150 x 50 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_76_98; Uniclass2015Title: WC Pan Back Rests; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-PAD-WH
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_WhiteBackRestPad; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WCPanBackRests_WhiteBackRestPad_BC5083-PAD-WH_DolphinSolutionsLimited; Category: Pr_40_20_76_98:WCPanBackRests
Pset_DistributionFlowElementCommon - Reference: BC5083-PAD-WH:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 584 mm; Host: Level : Level 0; Offset from Host: 584 mm
Dimensions - Area: 0.0714727 m2; Volume: 0.00253893 m3
Identity Data - Mark: 683
Other - Family: BC5083-PAD-WH: Standard; Family and Type: BC5083-PAD-WH: Standard; Type: BC5083-PAD-WH: Standard; Type Id: BC5083-PAD-WH: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC725:BC725 (2)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_15:Clothes hooks; CodePerformance: n/a; Color: Brushed Satin or RALPowderCoated; Constituents: n/a; Description: Clothes hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin or RALPowderCoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC725/BC725PC; ModelReference: DolphinSolutionsLimited_ClothesHooks; Name: Clothes hooks_BC725_DolphinSolutionsLimited; NBSDescription: Clothes hooks; NBSReference: 45-35-72/322; NBSTypeID: n/a; NominalHeight: 0; NominalLength: 60; NominalWidth: 48; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.31; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/single-robe-hook-bc725/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 60 x 48 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC725; Uniclass2015Code: Pr_40_30_78_15; Uniclass2015Title: Clothes hooks; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC725
Type - Pset_ElementShading - Color: Brushed Satin or RALPowderCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ClothesHooks; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Clothes hooks_BC725_DolphinSolutionsLimited; Category: Pr_40_30_78_15:Clothes hooks
Pset_DistributionFlowElementCommon - Reference: BC725:BC725; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Host: Level : Level 0
Dimensions - Area: 0.00466682 m2; Volume: 0.0000330174 m3
Other - Family: BC725: BC725; Family and Type: BC725: BC725; Type: BC725: BC725; Type Id: BC725: BC725
Phasing - Phase Created: New Construction
Name (BC725:BC725:...) | Elevation from Level (mm) = Offset from Host (mm) | Mark
356954 | 1050 | 14
356955 | 1400 | 15

# IfcFlowTerminal: BC727:BC727, BC727:BC727:1094385
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 133 mm; Height: 391 mm; Width: 88 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_86:Toilet brush holders; CodePerformance: n/a; Color: Brush Satin or RALPowdercoated; Constituents: n/a; Description: Toilet brush holder; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brush Satin or RALPowdercoated; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC727/BC727PC; ModelReference: DolphinSolutionsLimited_ToiletBrushHolder; Name: ToiletBrushHolder_BC727_DolphinSolutionsLimited; NBSDescription: Toilet brush holders; NBSReference: 45-35-72/364; NBSTypeID: n/a; NominalHeight: 391; NominalLength: 133; NominalWidth: 88; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-toilet-brush-set-bc727/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 88 x 391 x 133 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC727; Uniclass2015Code: Pr_40_20_76_86; Uniclass2015Title: Toilet brush holders; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC727
Type - Pset_ElementShading - Color: Brush Satin or RALPowdercoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ToiletBrushHolder; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ToiletBrushHolder_BC727_DolphinSolutionsLimited; Category: Pr_40_20_76_86:Toilet brush holders
Pset_DistributionFlowElementCommon - Reference: BC727:BC727; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 100 mm; Host: Level : Level 0; Offset from Host: 100 mm
Dimensions - Area: 0.0857889 m2; Volume: 0.000302901 m3
Identity Data - Mark: 669
Other - Family: BC727: BC727; Family and Type: BC727: BC727; Type: BC727: BC727; Type Id: BC727: BC727
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC751:BC751, BC751:BC751:1094386
In: Level 0
Type - Material: Default
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 170 mm; Height: 50 mm; Width: 250 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_06:BathroomShelves; CodePerformance: n/a; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC751; ModelReference: DolphinSolutionsLimited_ColostomyShelf; Name: BathroomShelves_ColostomyShelf_BC751_DolphinSolutionsLimited; NBSDescription: BathroomShelves; NBSReference: 45-35-72/354; NBSTypeID: n/a; NominalHeight: 50; NominalLength: 250; NominalWidth: 150; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.11; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-shelf-bc751/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 150 x 250 x 50 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC751; Uniclass2015Code: Pr_40_30_78_06; Uniclass2015Title: BathroomShelves; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Materials and Finishes - Primary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: BC751
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ColostomyShelf
Type - Pset_ProductRequirements - Name: BathroomShelves_ColostomyShelf_BC751_DolphinSolutionsLimited; Category: Pr_40_30_78_06:BathroomShelves
Pset_DistributionFlowElementCommon - Reference: BC751:BC751; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 900 mm; Host: Level : Level 0; Offset from Host: 900 mm
Dimensions - Area: 0.0682907 m2; Volume: 0.000134839 m3
Identity Data - Mark: 670
Other - Family: BC751: BC751; Family and Type: BC751: BC751; Type: BC751: BC751; Type Id: BC751: BC751
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC951:BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin, BC951:BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin:356949
In: Level 0
Type - Material: Default (6)
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 170 mm; Height: 542 mm; Width: 282 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Capacity: 24 litres; Category: Pr_40_50_07_96:WasteBins; CodePerformance: n/a; Color: Brushed Satin; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Plastic liner; Finish: Brushed Satin; Form: WallOrFloorMounted; Grade: 304; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC951; ModelReference: DolphinSolutionsLimited_FloorStandingOrWallMountedWasteBin; Name: WasteBins_FloorStandingOrWallMountedWasteBin_BC951_DolphinSolutionsLimited; NBSDescription: Waste bins; NBSReference: 45-35-72/380; NBSTypeID: n/a; NominalHeight: 542; NominalLength: 170; NominalWidth: 282; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.31.11; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-free-standing-surface-mounted-bin/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 282 x 542 x 170 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Uniclass2015Code: Pr_40_50_07_96; Uniclass2015Title: Waste bins; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Materials and Finishes - Primary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: BC951
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_FloorStandingOrWallMountedWasteBin
Type - Pset_ProductRequirements - Name: WasteBins_FloorStandingOrWallMountedWasteBin_BC951_DolphinSolutionsLimited; Category: Pr_40_50_07_96:WasteBins
Pset_DistributionFlowElementCommon - Reference: BC951:BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Host: Level : Level 0; Offset from Host: 0 mm
Dimensions - Area: 0.535081 m2; Volume: 0.000583357 m3
Identity Data - Mark: 9
Other - Family: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Family and Type: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Type: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin; Type Id: BC951: BC951 Dolphin Stainless Steel Free Standing / Surface Mounted Bin
Phasing - Phase Created: New Construction

# IfcFlowTerminal: BC958:BC958, BC958:BC958:1094389
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 103 mm; Height: 369 mm; Width: 281.5 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_70_22_62:Paper towel dispensers; CodePerformance: n/a; Color: Brushed Satin; Constituents: n/a; Description: Paper towel dispenser; DurationUnit: year; ExpectedLife: n/a; Features: Locakble; Finish: Brushed Satin; Form: Wall-mounted; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlesSteel; ModelNumber: BC958; ModelReference: DolphinSolutionsLimited_PaperTowelDispenser; Name: PaperTowelDispensers_Prestige_PaperTowelDispenser_BC958_DolphinSolutionsLimited; NBSDescription: Paper towel dispensers; NBSReference: 45-35-72/344; NBSTypeID: n/a; NominalHeight: 369; NominalLength: 103; NominalWidth: 282; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.21.17; Operation: Pull-out; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-paper-towel-dispenser-bc958/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 282 x 369 x 103 mm; SustainabilityPerformance: n/a; TagNumber: n/a; TowelCapacity: 400; Type Name: BC958; Uniclass2015Code: Pr_40_70_22_62; Uniclass2015Title: Paper towel dispensers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC958
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_PaperTowelDispenser; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: PaperTowelDispensers_Prestige_PaperTowelDispenser_BC958_DolphinSolutionsLimited; Category: Pr_40_70_22_62:Paper towel dispensers
Pset_DistributionFlowElementCommon - Reference: BC958:BC958; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 1000 mm; Host: Level : Level 0; Offset from Host: 1000 mm
Dimensions - Area: 0.176441 m2; Volume: 0.01063 m3
Identity Data - Mark: 673
Other - Family: BC958: BC958; Family and Type: BC958: BC958; Type: BC958: BC958; Type Id: BC958: BC958
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB5511.M:DB5511.M, DB5511.M:DB5511.M:1094395
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Box_20to90: 90 mm; Depth: 126 mm; Feet_0to200: 52 mm; Height: 1202 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_89:WCCisterns; CodePerformance: EN14055ClassTwoCompliant_WRAS_ApprovedInletValve; Color: White; Constituents: n/a; Description: 126mm Pneumatic WC Cistern 1150mm frame; DurationUnit: year; ExpectedLife: n/a; Features: AUK_BackflowArrangement_Dual flush in-wall cistern compatible with dual flush actuators 6/3 litres (adjustable to 4.5/3)_Delayed refilling (saves up to 9 litres of water per day) BS1212- 4:2016_Working pressure from 0.1 to 16 bar Resistance to atmospheric humidity (Hr <90%)_0-200mm adjustable height; Finish: n/a; Grade: n/a; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Polypropylene_TubularPaintedCorrosionResistantFrame; ModelNumber: DB5511.M; ModelReference: DolphinSolutionsLimited_PneumaticCiestern1150mmFrame; Name: WCCisterns_PneumaticCistern1150mmFrame_DB5511.M_DolphinSolutionsLimited; NBSDescription: WC Cisterns; NBSReference: 45-35-70/383; NBSTypeID: n/a; NominalHeight: 1150 mm; NominalLength: 126 mm; NominalWidth: 500 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.05.21.14.14; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-blue-126mm-pneumatic-cistern-1150mm-frame/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 500 x 1150 x 126 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB5511.M; Uniclass2015Code: Pr_40_20_93_89; Uniclass2015Title: WC Cisterns; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB5511.M
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_PneumaticCiestern1150mmFrame; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WCCisterns_PneumaticCistern1150mmFrame_DB5511.M_DolphinSolutionsLimited; Category: Pr_40_20_93_89:WCCisterns
Pset_DistributionFlowElementCommon - Reference: DB5511.M:DB5511.M; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Offset from Host: 0 mm; Host: Level : Level 0
Dimensions - Area: 1.04422 m2; Volume: 0.0253242 m3; Width: 500 mm
Identity Data - Mark: 679
Other - Family: DB5511.M: DB5511.M; Family and Type: DB5511.M: DB5511.M; Type: DB5511.M: DB5511.M; Type Id: DB5511.M: DB5511.M
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB5560.M:DB5560.M, DB5560.M:DB5560.M:1094396
In: Level 0
Type - PredefinedType: USERDEFINED; Material: <Unnamed> (8)
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 160 mm; Length: 48 mm; Width: 265 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_75_50_46_31:Flush control devices; CAWS: N13/300 WCs and cisterns_S90/690 Flush control devices_S90/690 Flush control devices; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: DocM Flush Plate; DurationUnit: year; ExpectedLife: n/a; Features: DocM Large Push Panels; Finish: DB5560.M.1_BrushedSatin_DB5560.M.2_Polished_DB5560.M.3_PVD_DB5560.M.5_PowderCoated_DB5560.M.6_CeramicCoated; Grade: 316; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; Material: StainlessSteel; ModelNumber: DB5560.M; ModelReference: DolphinSolutionsLimited_DocMFlushPlate; Name: FlushControlDevices_DocMFlushPlate_DB5560.M_DolphinSolutionsLimited; NBSCode: 90-15-35/470 Flush control devices; NBSDescription: Flush control devices; NBSReference: n/a; NBSTypeID: n/a; NominalHeight: 160 mm; NominalLength: 48 mm; NominalWidth: 265 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.60.50.24; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 160 x 265 x 48 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB5560.M; Uniclass2015Code: Pr_75_50_46_31; Uniclass2015Title: Flush control devices; Uniclass2015Version: Products v1.22; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB5560.M
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_DocMFlushPlate; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: FlushControlDevices_DocMFlushPlate_DB5560.M_DolphinSolutionsLimited; Category: Pr_75_50_46_31:Flush control devices
Pset_DistributionFlowElementCommon - Reference: DB5560.M:DB5560.M; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 973.553 mm; Host: Level : Level 0; Offset from Host: 973.553 mm
Dimensions - Area: 0.0880911 m2; Volume: 0.000768347 m3
Identity Data - Mark: 680
Other - Family: DB5560.M: DB5560.M; Family and Type: DB5560.M: DB5560.M; Type: DB5560.M: DB5560.M; Type Id: DB5560.M: DB5560.M
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB590:Standard, DB590:Standard:1094384
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 750 mm; Height: 460 mm; Width: 355 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_94:WC Pans; CodePerformance: EN997�CL2_DocM; Color: White; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Flush volume 6/3 litres; Finish: Gloss; Form: BaskToWallFloorMounted; Grade: n/a; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Ceramic; ModelNumber: DB590; ModelReference: DolphinSolutionsLimited_WCPan; Name: WCPans_DocM_WCPanFloorMounted_DB590_DolphinSolutionsLimited; NBSDescription: WC Pans; NBSReference: 35-70-70/134; NBSTypeID: n/a; NominalHeight: 460 mm; NominalLength: 750 mm; NominalWidth: 355 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.05.21.11.11; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-doc-m-floor-mounted-toilet-pan/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 355 x 460 x 750 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_93_94; Uniclass2015Title: WC Pans; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB590
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_WCPan
Type - Pset_ProductRequirements - Name: WCPans_DocM_WCPanFloorMounted_DB590_DolphinSolutionsLimited; Category: Pr_40_20_93_94:WC Pans
Pset_DistributionFlowElementCommon - Reference: DB590:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 0 mm; Offset from Host: 0 mm; Host: Level : Level 0
Dimensions - Area: 0.868335 m2; Volume: 0.0770681 m3
Identity Data - Mark: 668
Other - Family: DB590: Standard; Family and Type: DB590: Standard; Type: DB590: Standard; Type Id: DB590: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB591-GRY:DB591-GRY, DB591-GRY:DB591-GRY:1094397
In: Level 0
Type - PredefinedType: WCSEAT; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 20 mm; Length: 440 mm; Width: 353 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_95:WC seats and covers; CAWS: N13/300 WCs and cisterns; CodePerformance: DocM; Color: Grey; Constituents: n/a; Description: Grey Toilet seat; DurationUnit: year; ExpectedLife: n/a; Features: antibacterial_seat-only; Finish: n/a; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: WCSEAT; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: DB591-GRY; Material: ThermosetPlastic; ModelNumber: DB591-GRY; ModelReference: DolphinSolutionsLimited_ToiletSeat; Name: WCSeatsAndCovers_ToiletSeat_DB591-GRY_DolphinSolutionsLimited; NBSDescription: WC seats and covers; NBSReference: 45-35-70/391; NBSTypeID: n/a; NominalHeight: 20 mm; NominalLength: 440 mm; NominalWidth: 353 mm; ObjectClassification: 23.45.05.21.14.11; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 353 x 20 x 440 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB591-GRY; Uniclass2015Code: Pr_40_20_93_95; Uniclass2015Title: WC seats and covers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB591-GRY
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ToiletSeat; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WCSeatsAndCovers_ToiletSeat_DB591-GRY_DolphinSolutionsLimited; Category: Pr_40_20_93_95:WC seats and covers
Pset_DistributionFlowElementCommon - Reference: DB591-GRY:DB591-GRY; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 460 mm; Host: Level : Level 0; Offset from Host: 460 mm
Dimensions - Area: 0.111893 m2; Volume: 0.0017476 m3
Identity Data - Mark: 681
Other - Family: DB591-GRY: DB591-GRY; Family and Type: DB591-GRY: DB591-GRY; Type: DB591-GRY: DB591-GRY; Type Id: DB591-GRY: DB591-GRY
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB784.1:DB784.1, DB784.1:DB784.1:1094391
In: Level 0
Type - PredefinedType: WASTETRAP; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 160 mm; Length: 320.25 mm; Width: 32 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_70_55_96_97:Wash basins wastes; CodePerformance: BS EN 274-1:2002 and Approved Document H; Color: BrushedSatin_Polished_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Waste Trap; DurationUnit: year; ExpectedLife: n/a; Features: 1 1/4" Waste_75mmWaterSeal; Finish: Suffix_SS-316BrushedSatin; Grade: 316; IfcExportAs: IfcWasteTerminalType; IfcExportType: WASTETRAP; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: DB784.1; ModelReference: DolphinSolutionsLimited_Dolphin_Blue_WasteTrap; Name: WasteTrap_Blue_SatinSS316_DB784.1_DolphinSolutionsLimited; NBSDescription: Wash basins wastes; NBSReference: 45-35-70/372; NBSTypeID: n/a; NominalHeight: 160; NominalLength: 320; NominalWidth: 32; ObjectClassification: 23.45.55.00; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: DB784.1; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Size: 160x320x32; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB784.1; Uniclass2015Code: Pr_70_55_96_97; Uniclass2015Title: Wash basins wastes; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB784.1
Type - Pset_ElementShading - Color: BrushedSatin_Polished_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Dolphin_Blue_WasteTrap; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WasteTrap_Blue_SatinSS316_DB784.1_DolphinSolutionsLimited; Category: Pr_70_55_96_97:Wash basins wastes
Pset_DistributionFlowElementCommon - Reference: DB784.1:DB784.1; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 440 mm; Host: Level : Level 0; Offset from Host: 440 mm
Dimensions - Area: 0.0645665 m2; Volume: 0.000375945 m3
Identity Data - Mark: 675
Other - Family: DB784.1: DB784.1; Family and Type: DB784.1: DB784.1; Type: DB784.1: DB784.1; Type Id: DB784.1: DB784.1
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB793S:DB794S, DB793S:DB794S:1094392
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_70_55_96_97:Wash basins wastes; CodePerformance: n/a; Color: BrushedSatin or PowderCoatedRAL; Constituents: n/a; Description: Waste Drain; DurationUnit: year; ExpectedLife: n/a; Features: 1 1/4 waste_Slotted; Finish: BrushedChrome or PowderCoatedRAL; Grade: n/a; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass; ModelNumber: DB793S/DB793-PC; ModelReference: DolphinSolutionsLimited_WasteDrain; Name: WasteDrain_Blue_DB793S_DolphinSolutionsLimited; NBSDescription: Wash basins wastes; NBSReference: 45-35-70/372; NominalHeight: 48mm; NominalLength: 0; NominalWidth: 63mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.55.00; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-blue-waste-drain/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 48 x 63 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB794S; Uniclass2015Code: Pr_70_55_96_97; Uniclass2015Title: Wash basins wastes; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB793S
Type - Pset_ElementShading - Color: BrushedSatin or PowderCoatedRAL
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_WasteDrain; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WasteDrain_Blue_DB793S_DolphinSolutionsLimited; Category: Pr_70_55_96_97:Wash basins wastes
Pset_DistributionFlowElementCommon - Reference: DB793S:DB794S; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 661.735 mm; Host: Level : Level 0; Offset from Host: 661.735 mm
Dimensions - Area: 0.0175881 m2; Volume: 0.0000437176 m3
Identity Data - Mark: 676
